# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\LED;..\HARDWARE\24CXX;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\IIC;..\HARDWARE\IIC2;..\HARDWARE\TIMER;..\HARDWARE\DS3231;..\HARDWARE\ESP8266;..\HARDWARE\DHT11;..\HARDWARE\SG90;..\HARDWARE\AS608;..\HARDWARE\JQ8900;..\HARDWARE\RGB_LED;..\NET\MQTT;..\NET\cJSON;..\NET\DRUG;..\Middlewares\LVGL\GUI;..\Middlewares\LVGL\GUI\lvgl;..\Middlewares\LVGL\GUI\lvgl\src;..\Middlewares\LVGL\GUI\lvgl\examples\porting;..\Middlewares\LVGL\GUI_APP;..\Middlewares\LVGL\GUI_APP\ui;..\Middlewares\LVGL\GUI_APP\ui\screens;..\Middlewares\LVGL\GUI_APP\ui\fonts;..\Middlewares\LVGL\GUI_APP\ui\images
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c lvgl_demo.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DS3231/: ds3231.c
    ../HARDWARE/IIC2/: iic2.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/SG90/: sg90.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/JQ8900/: jq8900.c
    ../HARDWARE/RGB_LED/: rgb_led.c
  group NET
    ../NET/cJSON/: cJSON.c
    ../NET/MQTT/: mqtt.c
    ../NET/DRUG/: drug.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_tim.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Middlewares/lvgl/example/porting
    ../Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group Middlewares/lvgl/src/core
    ../Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Middlewares/lvgl/src/extra
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group Middlewares/lvgl/src/font
    ../Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/gpu
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Middlewares/lvgl/src/hal
    ../Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/misc
    ../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/widgets
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/LVGL/GUI_APP
    ../Middlewares/LVGL/GUI_APP/ui/: ui.c ui_helpers.c
    ../Middlewares/LVGL/GUI_APP/ui/screens/: ui_DrugManageScr.c ui_MainScr.c ui_SettingScr.c ui_StartScr.c
    ../Middlewares/LVGL/GUI_APP/ui/fonts/: ui_font_SourceHanSansCN30.c
    ../Middlewares/LVGL/GUI_APP/ui/images/: ui_img_back_png.c ui_img_drug_png.c ui_img_setting_png.c ui_img_close_png.c
  group README
    ../: readme.txt
